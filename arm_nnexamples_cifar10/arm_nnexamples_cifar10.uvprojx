# Keil uVision project arm_nnexamples_cifar10.uvprojx, settings and files
target ARMCM0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arm_nnexample_cifar10
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./src/: arm_nnexamples_cifar10.cpp
  group Documentation
    ./: readme.txt
target ARMCM3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_nnexample_cifar10
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4_FP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_nnexample_cifar10
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U
  c include: ..\..\..\..\Include;..\..\..\..\..\Core\Include;..\..\..\..\..\DSP\Include;..\cifar10
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM7_SP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_nnexample_cifar10
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM7 __FPU_PRESENT=1U
  c include: ..\..\..\..\Include;..\..\..\..\..\Core\Include;..\..\..\..\..\DSP\Include;.\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, CMSIS:NN Lib 1.0.0, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Compiler:Event Recorder 1.2.1, Compiler:I/O:STDOUT 1.2.1, Compiler:I/O:STDOUT 1.2.1
